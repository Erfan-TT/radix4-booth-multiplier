

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO boothmul_registered 
  PIN CLK 
    ANTENNAPARTIALMETALAREA 8.5162 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.2216 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.12375 LAYER metal4 ; 
    ANTENNAMAXAREACAR 130.155 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 522.252 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.475152 LAYER via4 ;
  END CLK
  PIN LD 
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.26125 LAYER metal4 ; 
    ANTENNAMAXAREACAR 3.79809 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 15.3022 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.131292 LAYER via4 ;
  END LD
  PIN RST 
    ANTENNAPARTIALMETALAREA 0.784 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.136 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.26125 LAYER metal4 ; 
    ANTENNAMAXAREACAR 5.86794 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 22.4515 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.131292 LAYER via4 ;
  END RST
  PIN A[31] 
    ANTENNAPARTIALMETALAREA 0.41895 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6758 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.3321 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 49.6632 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[31]
  PIN A[30] 
    ANTENNAPARTIALMETALAREA 0.55195 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2078 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 18.8163 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 75.6 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[30]
  PIN A[29] 
    ANTENNAPARTIALMETALAREA 0.47215 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8886 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 13.7254 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 55.2364 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[29]
  PIN A[28] 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 19.7005 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 76.0096 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[28]
  PIN A[27] 
    ANTENNAPARTIALMETALAREA 0.57855 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3142 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 20.3971 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 81.9234 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[27]
  PIN A[26] 
    ANTENNAPARTIALMETALAREA 0.39235 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5694 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 11.0727 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 44.6258 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[26]
  PIN A[25] 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 11.5148 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 44.2124 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[25]
  PIN A[24] 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.2115 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 46.8536 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[24]
  PIN A[23] 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 14.4354 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 55.1675 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[23]
  PIN A[22] 
    ANTENNAPARTIALMETALAREA 0.57505 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3002 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.1311 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 48.8593 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[22]
  PIN A[21] 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 13.2163 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 49.7818 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[21]
  PIN A[20] 
    ANTENNAPARTIALMETALAREA 0.33915 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3566 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 14.0469 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 54.6316 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[20]
  PIN A[19] 
    ANTENNAPARTIALMETALAREA 0.80465 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2186 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 19.9014 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 79.9407 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[19]
  PIN A[18] 
    ANTENNAPARTIALMETALAREA 0.23275 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.931 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 10.0947 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 39.4775 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[18]
  PIN A[17] 
    ANTENNAPARTIALMETALAREA 0.52535 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1014 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 11.555 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 46.555 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[17]
  PIN A[16] 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 10.2153 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 38.7962 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[16]
  PIN A[15] 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 13.1359 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 49.7512 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[15]
  PIN A[14] 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.3722 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 46.9148 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[14]
  PIN A[13] 
    ANTENNAPARTIALMETALAREA 0.40565 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6226 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.45167 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 38.1416 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[13]
  PIN A[12] 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 8.50048 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 32.3732 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[12]
  PIN A[11] 
    ANTENNAPARTIALMETALAREA 0.20615 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8246 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.07656 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 35.5502 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[11]
  PIN A[10] 
    ANTENNAPARTIALMETALAREA 0.51835 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0734 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.9885 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 52.2163 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[10]
  PIN A[9] 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 11.4077 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 43.4928 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[9]
  PIN A[8] 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 8.63445 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 32.7636 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[8]
  PIN A[7] 
    ANTENNAPARTIALMETALAREA 0.36575 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.463 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.50526 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 38.2833 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[7]
  PIN A[6] 
    ANTENNAPARTIALMETALAREA 0.36575 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.463 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 11.3809 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 45.7856 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[6]
  PIN A[5] 
    ANTENNAPARTIALMETALAREA 0.57505 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3002 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 15.1321 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 60.8632 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[5]
  PIN A[4] 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 17.8115 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 68.6718 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[4]
  PIN A[3] 
    ANTENNAPARTIALMETALAREA 0.44555 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7822 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.6 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 50.7349 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[3]
  PIN A[2] 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.667 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 48.3847 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[2]
  PIN A[1] 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 11.9703 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 45.7435 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[1]
  PIN A[0] 
    ANTENNAPARTIALMETALAREA 0.36575 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.463 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 11.689 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 47.0909 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END A[0]
  PIN B[31] 
    ANTENNAPARTIALMETALAREA 0.8036 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2144 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 18.3139 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 73.9656 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[31]
  PIN B[30] 
    ANTENNAPARTIALMETALAREA 0.8036 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2144 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 26.8909 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 107.34 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[30]
  PIN B[29] 
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 10.5033 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 42.7234 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[29]
  PIN B[28] 
    ANTENNAPARTIALMETALAREA 0.784 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.136 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 22.3325 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 89.0909 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[28]
  PIN B[27] 
    ANTENNAPARTIALMETALAREA 0.8036 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2144 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 16.9742 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 68.534 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[27]
  PIN B[26] 
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 10.9048 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 43.3799 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[26]
  PIN B[25] 
    ANTENNAPARTIALMETALAREA 2.2148 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.8592 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 49.5426 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 198.589 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[25]
  PIN B[24] 
    ANTENNAPARTIALMETALAREA 0.8036 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2144 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 18.501 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 73.7646 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[24]
  PIN B[23] 
    ANTENNAPARTIALMETALAREA 0.8036 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2144 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 16.7062 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 67.5349 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[23]
  PIN B[22] 
    ANTENNAPARTIALMETALAREA 0.8624 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4496 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 18.3301 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 73.0967 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[22]
  PIN B[21] 
    ANTENNAPARTIALMETALAREA 0.784 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.136 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 16.4316 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 66.4364 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[21]
  PIN B[20] 
    ANTENNAPARTIALMETALAREA 0.7448 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9792 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 17.1612 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 68.4057 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[20]
  PIN B[19] 
    ANTENNAPARTIALMETALAREA 0.8624 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4496 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 17.8852 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 72.2507 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[19]
  PIN B[18] 
    ANTENNAPARTIALMETALAREA 0.8428 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3712 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 17.7072 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 70.6029 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[18]
  PIN B[17] 
    ANTENNAPARTIALMETALAREA 0.8036 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2144 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 17.8316 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 72.0364 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[17]
  PIN B[16] 
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 9.53828 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 37.9139 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[16]
  PIN B[15] 
    ANTENNAPARTIALMETALAREA 0.8036 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2144 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 16.6794 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 67.4278 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[15]
  PIN B[14] 
    ANTENNAPARTIALMETALAREA 0.9212 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6848 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 23.7962 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 94.9608 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[14]
  PIN B[13] 
    ANTENNAPARTIALMETALAREA 0.8036 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2144 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 17.2287 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 69.6249 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[13]
  PIN B[12] 
    ANTENNAPARTIALMETALAREA 0.9604 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8416 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 20.1789 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 80.4919 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[12]
  PIN B[11] 
    ANTENNAPARTIALMETALAREA 0.8036 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2144 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 16.599 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 67.1062 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[11]
  PIN B[10] 
    ANTENNAPARTIALMETALAREA 0.8036 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2144 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 17.5632 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 70.0134 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[10]
  PIN B[9] 
    ANTENNAPARTIALMETALAREA 0.8036 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2144 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 17.0411 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 68.7292 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[9]
  PIN B[8] 
    ANTENNAPARTIALMETALAREA 0.8232 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2928 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 19.5761 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 78.0804 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[8]
  PIN B[7] 
    ANTENNAPARTIALMETALAREA 0.8036 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2144 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 18.9435 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 76.4115 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[7]
  PIN B[6] 
    ANTENNAPARTIALMETALAREA 0.5292 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1168 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 20.5105 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 81.8029 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[6]
  PIN B[5] 
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 12.6469 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 51.2976 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[5]
  PIN B[4] 
    ANTENNAPARTIALMETALAREA 1.176 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.704 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 34.0014 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 135.767 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[4]
  PIN B[3] 
    ANTENNAPARTIALMETALAREA 0.8036 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2144 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 24.7847 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 97.5215 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[3]
  PIN B[2] 
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 24.9751 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 99.3856 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[2]
  PIN B[1] 
    ANTENNAPARTIALMETALAREA 0.5096 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0384 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 43.2191 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 173.587 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[1]
  PIN B[0] 
    ANTENNAPARTIALMETALAREA 1.2152 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8608 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal4 ; 
    ANTENNAMAXAREACAR 40.7971 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 162.965 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.28134 LAYER via4 ;
  END B[0]
  PIN P[63] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.93345 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7534 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 19.3254 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 77.1694 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END P[63]
  PIN P[62] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.94395 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7758 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 19.7139 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 78.3483 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END P[62]
  PIN P[61] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.85365 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4342 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 17.6105 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 70.31 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END P[61]
  PIN P[60] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 1.01255 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0698 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 23.3914 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 94.023 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.37512 LAYER via3 ;
  END P[60]
  PIN P[59] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.17955 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7182 LAYER metal3 ;
  END P[59]
  PIN P[58] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.17955 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7182 LAYER metal3 ;
  END P[58]
  PIN P[57] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.51835 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0734 LAYER metal3 ;
  END P[57]
  PIN P[56] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.93695 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7478 LAYER metal3 ;
  END P[56]
  PIN P[55] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.17955 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7182 LAYER metal3 ;
  END P[55]
  PIN P[54] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 1.18615 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7446 LAYER metal3 ;
  END P[54]
  PIN P[53] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.48545 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9418 LAYER metal3 ;
  END P[53]
  PIN P[52] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.17955 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7182 LAYER metal3 ;
  END P[52]
  PIN P[51] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 1.21275 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.851 LAYER metal3 ;
  END P[51]
  PIN P[50] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.17955 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7182 LAYER metal3 ;
  END P[50]
  PIN P[49] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.17955 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7182 LAYER metal3 ;
  END P[49]
  PIN P[48] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 1.22255 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9098 LAYER metal3 ;
  END P[48]
  PIN P[47] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.17955 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7182 LAYER metal3 ;
  END P[47]
  PIN P[46] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.17955 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7182 LAYER metal3 ;
  END P[46]
  PIN P[45] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.72485 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8994 LAYER metal3 ;
  END P[45]
  PIN P[44] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 1.18685 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.767 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 28.4383 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 113.093 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END P[44]
  PIN P[43] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.49875 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.995 LAYER metal3 ;
  END P[43]
  PIN P[42] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.53865 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1546 LAYER metal3 ;
  END P[42]
  PIN P[41] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.51205 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0482 LAYER metal3 ;
  END P[41]
  PIN P[40] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.52535 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1014 LAYER metal3 ;
  END P[40]
  PIN P[39] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.53865 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1546 LAYER metal3 ;
  END P[39]
  PIN P[38] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.52535 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1014 LAYER metal3 ;
  END P[38]
  PIN P[37] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
  END P[37]
  PIN P[36] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.94675 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8066 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 20.7081 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 82.3177 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END P[36]
  PIN P[35] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.88095 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5434 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 17.9923 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 72.9761 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END P[35]
  PIN P[34] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.78785 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.171 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 16.2105 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 65.8488 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END P[34]
  PIN P[33] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.95725 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.829 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 19.6402 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 79.1923 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END P[33]
  PIN P[32] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.78085 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.143 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 18.2833 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 72.6182 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END P[32]
  PIN P[31] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.49875 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.995 LAYER metal3 ;
  END P[31]
  PIN P[30] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.21945 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8778 LAYER metal3 ;
  END P[30]
  PIN P[29] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.21945 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8778 LAYER metal3 ;
  END P[29]
  PIN P[28] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.48545 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9418 LAYER metal3 ;
  END P[28]
  PIN P[27] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.47215 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8886 LAYER metal3 ;
  END P[27]
  PIN P[26] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.71155 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8462 LAYER metal3 ;
  END P[26]
  PIN P[25] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.33915 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3566 LAYER metal3 ;
  END P[25]
  PIN P[24] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.54845 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1938 LAYER metal3 ;
  END P[24]
  PIN P[23] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.52535 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1014 LAYER metal3 ;
  END P[23]
  PIN P[22] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.48545 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9418 LAYER metal3 ;
  END P[22]
  PIN P[21] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
  END P[21]
  PIN P[20] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.51205 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0482 LAYER metal3 ;
  END P[20]
  PIN P[19] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.43225 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.729 LAYER metal3 ;
  END P[19]
  PIN P[18] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.49875 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.995 LAYER metal3 ;
  END P[18]
  PIN P[17] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.60515 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4206 LAYER metal3 ;
  END P[17]
  PIN P[16] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 1.35905 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.4558 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 28.7732 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 114.869 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END P[16]
  PIN P[15] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 1.17635 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7054 LAYER metal3 ;
  END P[15]
  PIN P[14] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.89075 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.563 LAYER metal3 ;
  END P[14]
  PIN P[13] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.81725 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.269 LAYER metal3 ;
  END P[13]
  PIN P[12] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 1.14555 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5822 LAYER metal3 ;
  END P[12]
  PIN P[11] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.84105 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3642 LAYER metal3 ;
  END P[11]
  PIN P[10] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.88445 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5378 LAYER metal3 ;
  END P[10]
  PIN P[9] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.67165 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6866 LAYER metal3 ;
  END P[9]
  PIN P[8] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
  END P[8]
  PIN P[7] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.49875 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.995 LAYER metal3 ;
  END P[7]
  PIN P[6] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.51205 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0482 LAYER metal3 ;
  END P[6]
  PIN P[5] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.68495 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7398 LAYER metal3 ;
  END P[5]
  PIN P[4] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.73815 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9526 LAYER metal3 ;
  END P[4]
  PIN P[3] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.71155 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8462 LAYER metal3 ;
  END P[3]
  PIN P[2] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 1.36255 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.4502 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal3 ; 
    ANTENNAMAXAREACAR 27.1493 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 108.595 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.18756 LAYER via3 ;
  END P[2]
  PIN P[1] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 2.01425 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.057 LAYER metal3 ;
  END P[1]
  PIN P[0] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.83125 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.325 LAYER metal3 ;
  END P[0]
END boothmul_registered

END LIBRARY
